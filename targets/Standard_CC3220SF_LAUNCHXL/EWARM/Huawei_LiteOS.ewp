# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3220SF TexasInstruments CC3220SF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\Drivers\cc32xx\inc; ..\Inc; ..\OS_CONFIG; ..\..\..\arch\arm\arm-m\include; ..\..\..\arch\arm\arm-m\cortex-m4; ..\..\..\kernel\base\include; ..\..\..\kernel\include; ..\..\..\components\cmsis; ..\..\..\components\cmsis\1.0; ..\..\..\components\cmsis\2.0; ..\..\..\arch\arm\common\cmsis; $TOOLKIT_DIR$\..\..\..\..\ti\simplelink_cc32xx_sdk_2_20_00_10\source; ..\Drivers\simplelink_cc32xx_sdk_2_20_00_10\kernel\nortos
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.srec
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: E:\Huawei_LiteOS\LiteOS\targets\Standard_CC3220SF_LAUNCHXL\EWARM\CC3220SF_LAUNCHXL_FREERTOS.icf
  ILINK.IlinkExtraOptions: $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4/grlib.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4/spiffs.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc32xx.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/third_party/fatfs/lib/iar/m4/fatfs.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/nortos/lib/nortos_cc32xx.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/devices/cc32xx/driverlib/iar/Release/driverlib.a; --silent; --cpu=Cortex-M4; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/drivers/Startup
    ../Drivers/simplelink_cc32xx_sdk_2_20_00_10/kernel/nortos/: NoRTOS.c
    ../Drivers/simplelink_cc32xx_sdk_2_20_00_10/kernel/nortos/startup/: startup_cc32xx_iar.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/iar/: los_dispatch_iar.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group user
    ../Src/: Board.h CC3220SF_LAUNCHXL.c main.c sys_init.c usart.c
